Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Bubble table basse.IFC
Time: 2020-09-14T14:01:04
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 102166_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: 102167_Default (43)
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: 102168_Default
In: Default Storey
Material: AISI 304
PSet_Mass_Property - Mass Measure: 17.1509; Area Measure: 1.25388 m2; Volume Measure: 0.00214387 m3

# IfcBuildingElementProxy: 102179_Default (8)
In: Default Storey
Material: AISI 304
